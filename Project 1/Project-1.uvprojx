# Keil uVision project Project-1.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project-1
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __MSP432P401R__
  asm define: __MSP432P401R__
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source Group 1
    ./: ADC14.c Camera.c ControlPins.c CortexM.c i2c.c Motors.c Lab1.c Project-Main.c oled.c SysTickTimer.c TimerA.c Timer32.c uart.c ADC14.h Camera.h Common.h ControlPins.h CortexM.h Lab1.h i2c.h leds.h oled.h TimerA.h Timer32.h SysTickTimer.h uart.h Motors.h PID.c PID.h
software components: CMSIS:CORE 5.5.0, Device:Startup 3.2.2
